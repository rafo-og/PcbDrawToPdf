# Repository rafo-og/PcbDrawToPdf

File README.md:

# PcbDrawToPdf

Convert the SVG files generated by [PcbDraw](https://github.com/yaqwsx/PcbDraw) to PDF files.

This tool addresses the challenge of exporting PDF files from PcbDraw, particularly related to the SVG mask property that Inkscape does not convert properly. It processes the SVG file generated by [PcbDraw](https://github.com/yaqwsx/PcbDraw) and produces another SVG file without the masks. The masks are exported as additional groups, allowing for their application in other software, such as Adobe Illustrator.

# Installation

PcbDrawToPdf is a stand-alone CLI tool. PcbDrawToPdf is tested with Inkscape 1.3.2 and PcbDraw v1.1.2.

PcbDrawToPdf is distributed as a Python package. You just have to follow the installation [instructions from PcbDraw](https://github.com/yaqwsx/PcbDraw/blob/v1.1.2/doc/installation.md) and then install PcbDrawToPdf via Pip:

```
pip install PcbDrawToPdf # Use pip or pip3 based on your distribution
```

Now you can test that it works:

```.bash
pcbdrawtopdf --help
```

You should get a help menu.

## Usage

The input for PcbDrawToPdf is the SVG file generated by [PcbDraw](https://github.com/yaqwsx/PcbDraw). This tool provides this command:

- **`convert-masks`**: This command generates a new SVG file by removing the mask effects and adding the masks to an additional group called `masks`. These masks must be applied in Adobe Illustrator from the lowest hierarchy level to the highest. The groups that need masking are renamed with `_<mask-name>`, where `<mask-name>` corresponds to the name of the group containing the mask.

### Mask Application

PcbDraw generates three masks: `hole-mask`, `pads-mask-silkscreen`, and `pads-mask`. The masks should be applied in the following order:

1. `pads-mask-silkscreen`
2. `pads-mask`
3. `hole-mask`

This order is important because `hole-mask` applies to a group at a higher hierarchy level in the SVG file.

See the section below to learn about applying opacity masks in Adobe Illustrator. Moreover, the mask property `Drop` must ticked and the property `Invert` doesn't.

Once the masks are applied, they can be removed.

## Additional Resources

For more information about applying opacity masks in Adobe Illustrator, please refer to this [video](https://www.youtube.com/live/dgZw71lGOAE?si=zoRidVZViH9u8Fft).

## Examples

```
pcbdrawtopdf convert-masks ArduinoLearningKitStarter.svg ArduinoLearningKitStarter_export.svg
```

```
pcbdrawtopdf extract-masks ArduinoLearningKitStarter.svg export_folder
```

## KiCad design test/ArduinoLearningKitStarter.kicad_pcb

Board: 2 copper layers, 83.0 x 58.5 mm, 80 parts (41 on the bottom side), 70 nets.

Parts:
C1, C2, C3: 10n; C_1206_HandSoldering
C4, C5, C7, C8: 10uF; C_0805_HandSoldering
C6: 10 μF; C_0805_HandSoldering
DHT11: DHT11_CONN; PinHeader_1x04_P2.54mm_Vertical
J1: USB_OTG; USB_Micro-B-widened
J2, J4: CONN_01X08; PinHeader_1x08_P2.54mm_Vertical
J3: CONN_01X06; PinHeader_1x06_P2.54mm_Vertical
J5: CONN_01X10; PinHeader_1x10_P2.54mm_Vertical
J6: CONN_01X04; PinHeader_1x04_P2.54mm_Horizontal
J7: CONN_01X04; PinHeader_1x04_P2.54mm_Vertical
J8: CONN_01X02; PinHeader_1x02_P2.54mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP10, JP11, JP12, JP13, JP14, JP15: Jumper_NC_Small; CUT_BRIDGGE
JP9, JP16, JP17: Jumper; Pin_Header_Straight_1x02
JP18: Jumper_NC_Dual; PinHeader_1x03_P2.54mm_Vertical
L_B1: LED; LED_D5.0mm
L_G1: LED; LED_D5.0mm
L_R1: LED; LED_D5.0mm
L_RGB1: LED_RCBG; LED_D5.0mm-4_RGB
L_Y1: LED; LED_D5.0mm
PHOTO1: Photores; Resistor_Horizontal_RM7mm
PIEZO1: PIEZO; piezo_12
R1, R2, R13, R14, R15, R19, R20, R21, R22, R23, R24, R25: 1k; R_1206_HandSoldering
R3: 20k; R_1206_HandSoldering
R4, R10, R11, R12: 10k; R_1206_HandSoldering
R5, R6, R7, R8, R9, R16, R17, R18: 220R; R_1206_HandSoldering
RV1, RV2: 10k; RV09
S1: SERVO1; PinHeader_1x03_P2.54mm_Vertical
S2: SERVO2; PinHeader_1x03_P2.54mm_Vertical
S3: SERVO3; PinHeader_1x03_P2.54mm_Vertical
S4: SERVO4; PinHeader_1x03_P2.54mm_Vertical
S5: SERVO5; PinHeader_1x03_P2.54mm_Vertical
SW1, SW2, SW3: SW_PUSH; SW_PUSH_6mm
U1: arduino_nano
U2: arduino_uno; arduino_uno_small_pads
U3: ESP32-DEVKIT-C

Connections:
+3V3: J2.4, JP18.3, U1.2, U2.4, U3.1
+5V: J2.5, J2.6, J2.7, J2.8, JP9.1, JP18.1, U1.12, U2.5, U3.19
/D+: J1.3, J8.1
/D-: J1.2, J8.2
A0: JP2.1, U1.4, U2.9, U3.7
A1: JP3.1, U1.5, U2.10, U3.8
A2: JP1.1, U1.6, U2.11, U3.9
A3: DHT11.2, J7.3, U1.7, U2.12, U3.10
A4: U1.8, U2.13, U2.31, U3.11
A5: U1.9, U2.14, U2.32, U3.12
A6: U1.10, U3.13
A7: U1.11, U3.15
AREF: U1.3, U2.30
D0: R23.1, U1.17, U2.15, U3.34
D1: R24.1, U1.16, U2.16, U3.35
D2: JP10.1, U1.20, U2.17, U3.23
D3: JP11.1, U1.21, U2.18, U3.24
D4: JP12.1, U1.22, U2.19, U3.25
D5: JP13.2, R25.1, U1.23, U2.20, U3.26
D6: JP14.2, R19.1, U1.24, U2.21, U3.27
D7: JP7.1, U1.25, U2.22, U3.28
D8: JP8.1, U1.26, U2.23, U3.29
D9: JP4.1, R20.1, U1.27, U2.24, U3.30
D10: JP16.2, R21.1, U1.28, U2.25, U3.31
D11: JP15.2, R22.1, U1.29, U2.26, U3.33
D12: JP5.1, U1.30, U2.27, U3.36
D13: JP6.1, U1.1, U2.28, U3.37
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, DHT11.4, J1.5, J1.6, J2.1, J2.3, J3.1, J3.2, J3.3, J3.4, J3.5, J3.6, J4.1, J4.2, J4.3, J4.4, J4.5, J4.6, J4.7, J4.8, J5.1, J5.2, J5.3, J5.4, J5.5, J5.6, J5.7, J5.8, J5.9, J5.10, J6.3, J7.1, L_RGB1.2, R3.1, R4.2, R5.1, R6.1, R8.1, R9.1, RV1.1, RV2.1, S1.1, S2.1, S3.1, S4.1, S5.1, SW1.2, SW2.2, SW3.2, U1.14, U1.19, U2.6, U2.7, U2.29, U3.14, U3.32, U3.38
IOREF: J2.2, U2.2
IOREF_U: DHT11.1, J6.4, J7.4, JP18.2, PHOTO1.1, R10.1, R11.1, R12.1, RV1.3, RV2.3
unnamed: C1.2, JP17.2, R10.2
unnamed: C2.2, R14.1, SW2.1
unnamed: C3.2, R15.1, SW3.1
unnamed: J6.1, R24.2
unnamed: J6.2, R23.2
unnamed: J7.2, R3.2
unnamed: JP1.2, PHOTO1.2, R4.1
unnamed: JP2.2, R1.2
unnamed: JP3.2, R2.2
unnamed: JP4.2, PIEZO1.2
unnamed: JP5.2, L_R1.2
unnamed: JP6.2, L_Y1.2
unnamed: JP7.2, L_G1.2
unnamed: JP8.2, L_B1.2
unnamed: JP10.2, R13.2
unnamed: JP11.2, R11.2, R14.2
unnamed: JP12.2, R12.2, R15.2
unnamed: JP13.1, R16.1
unnamed: JP14.1, R17.1
unnamed: JP15.1, R18.1
unnamed: JP16.1, R7.1
unnamed: JP17.1, R13.1, SW1.1
unnamed: L_B1.1, R9.2
unnamed: L_G1.1, R8.2
unnamed: L_R1.1, R5.2
unnamed: L_RGB1.1, R16.2
unnamed: L_RGB1.3, R18.2
unnamed: L_RGB1.4, R17.2
unnamed: L_Y1.1, R6.2
unnamed: PIEZO1.1, R7.2
unnamed: R1.1, RV1.2
unnamed: R2.1, RV2.2
unnamed: R19.2, S2.3
unnamed: R20.2, S3.3
unnamed: R21.2, S4.3
unnamed: R22.2, S5.3
unnamed: R25.2, S1.3
RST: U1.13, U1.18, U2.3, U3.2
VCC: U1.15, U2.8
VCC_SERVO: C4.1, C5.1, C6.1, C7.1, C8.1, J1.1, JP9.2, S1.2, S2.2, S3.2, S4.2, S5.2

## Commit log

2024-07-24 Baseline.
2024-07-24 Adding docstrings.
2024-07-24 Updating README.
2024-07-24 Adding GitHub actions to publish to pypi index.
2024-07-24 Fixing GitHub action.
2024-07-24 Testing.
2024-07-24 Updating package folder name.
2024-07-24 Changing layout from src layout to flat layout.
2024-07-24 Updating package when release published.
2024-07-25 Uploading workflow and README file to show image on PyPi.
2024-07-25 Fixing workflow.
2024-07-25 Increasing package version to avoid conflicts on PyPi publication.
2024-07-25 Fixing file image link in README file.
2024-07-25 Fixing command line execution.
2024-07-25 Adding some auxiliary methods.
2024-07-25 Fixing some problems when PcbDraw exports the back side of the PCB.
2024-07-25 Fixing requires-python constrains in project.toml.
2024-11-13 Simplifying the code to make it cleaner. Changes: - The masks are grouped in its own group. - The export_mask function is removed.
2024-11-13 Fixing Readme and generating again the example.
2024-11-27 Adding log messages during the conversion process.
2024-11-27 Incrementing the version.
2024-11-27 Removing the publication to testpy repository.

Notices in the files:
test/ArduinoLearningKitStarter.kicad_pcb:
CC BY-SA 4.0
